# Keil uVision project ACMP.uvproj, settings and files
target ACMP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: ACMP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAVE_CONFIG_H,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\hw;..\rf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c prc.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c gpio.c timer.c dac.c eadc.c pdma.c sys.c spi.c
  group flt
    ../flt/: interf_dec.c interf_enc.c rom_dec.c rom_enc.c sp_dec.c sp_enc.c
  group mdm
    ../mdm/: mdm.c
  group hw
    ../hw/: spp.c aud.c com.c pdc.c gpc.c
  group rf
    ../rf/: cmt_spi3.c cmt2300a.c cmt2300a_hal.c radio.c radio_if.c
